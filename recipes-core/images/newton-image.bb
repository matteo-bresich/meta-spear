SUMMARY = "Production image"

IMAGE_FEATURES += ""

LICENSE = "MIT"

inherit core-image

IMAGE_CLASSES += "qemuboot"


CORE_IMAGE_EXTRA_INSTALL = ""
